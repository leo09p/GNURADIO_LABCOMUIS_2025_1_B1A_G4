options:
  parameters:
    generate_options: qt_gui
    id: Modulador_de_amplitud
    output_language: python
    title: Modulador de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la portadora (Ac)
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitudedel mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1.3'
  states: {state: disabled}
- name: B
  id: variable_qtgui_range
  parameters:
    label: '#muestra por simbolo'
    start: '1'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente ka
    start: '-8'
    step: '0.1'
    stop: '8'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de mensaje
    start: '300'
    step: '100'
    stop: 390.625e3
    value: 1e3
  states: {state: disabled}
- name: n
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5625e6
  states: {}
- name: Lab3_part1_0
  id: Lab3_part1
  parameters:
    Ac: Ac
    ka: Ka
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: int(math.pow(2,n))
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-(math.pow(2,n)-1)/2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/math.pow(2,n)
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: B
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: m_t
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: m_t
  states: {}

connections:
- [Lab3_part1_0, '0', qtgui_freq_sink_x_0, '0']
- [Lab3_part1_0, '0', qtgui_time_sink_x_0, '0']
- [Lab3_part1_0, '0', uhd_usrp_sink_0, '0']
- [analog_random_source_x_0, '0', blocks_uchar_to_float_0, '0']
- [analog_sig_source_x_0, '0', Lab3_part1_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_repeat_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0, '0']
- [virtual_source_0, '0', Lab3_part1_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
